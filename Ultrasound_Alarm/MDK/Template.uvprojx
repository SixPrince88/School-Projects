# Keil uVision project Template.uvprojx, settings and files
target Template (6220000::V6.22::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER
  c include: ..\CMSIS\startup\MDK;..\CMSIS;..\Libraries\inc;..\User;..\User\UserLibrary\inc;..\User\Common\inc;..\User\BSP\inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CMSIS
    ../CMSIS/startup/MDK/: startup_stm32f10x_md.s
    ../CMSIS/: core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group Libraries
    ../Libraries/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group User
    ../User/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
  group Common
    ../User/Common/src/: hw_i2c.c lowpass_filter.c pid.c sw_i2c.c
  group UserLiBrary
    ../User/UserLibrary/src/: my_adc.c my_delay.c my_dma.c my_exti.c my_gpio.c my_i2c.c my_nvic.c my_serial.c my_tim.c
  group BSP
    ../User/BSP/src/: hw_adc.c hw_key.c hw_motor.c hw_oled.c hw_signal.c hw_timestamp.c hw_fd07_3.c
software components: CMSIS:CORE 6.1.0
