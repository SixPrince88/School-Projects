# IAR project Template.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103C8 ST STM32F103C8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_HD
  ICCARM.CCIncludePath2: E:\ARM\BareMetal\STM32\Ultrasound_Alarm\CMSIS; E:\ARM\BareMetal\STM32\Tamplate\CMSIS\startup\MDK; E:\ARM\BareMetal\STM32\Tamplate\Libraries\inc; E:\ARM\BareMetal\STM32\Ultrasound_Alarm\User; E:\ARM\BareMetal\STM32\Ultrasound_Alarm\User\Common\inc; E:\ARM\BareMetal\STM32\Ultrasound_Alarm\User\UserLibrary\inc; E:\ARM\BareMetal\STM32\Ultrasound_Alarm\User\BSP\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Template.srec
  ILINK.IlinkOutputFile: Template.out
  ILINK.IlinkIcfFile: Config\stm32f10x_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Libraries/CMSIS
    ../CMSIS/: core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
    ../CMSIS/startup/IAR/: startup_stm32f10x_md.s
  group Libraries/Drivers
    ../Libraries/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group User
    ../User/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
  group User/BSP
    ../User/BSP/src/: hw_adc.c hw_fd07_3.c hw_key.c hw_motor.c hw_oled.c hw_qei.c hw_signal.c hw_timestamp.c
  group User/Common
    ../User/Common/src/: hw_i2c.c lowpass_filter.c pid.c sw_i2c.c
  group User/Library
    ../User/UserLibrary/src/: my_adc.c my_delay.c my_dma.c my_exti.c my_gpio.c my_i2c.c my_nvic.c my_serial.c my_tim.c
